# Keil uVision project fFt.uvprojx, settings and files
target fFt (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF)  CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: fFt +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC,USE_HAL_DRIVER,STM32F401xC,ARM_MATH_CM4, __CC_ARM, __TARGET_FPU_VFP
  c misc: --diag_suppress=2803,1,1035
  c include: ../Inc;                                                         ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                         ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                         ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                         ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Application/User
    ../Src/: main.c gpio.c adc.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group ssd1306
    ../Drivers/ssd1306/: ssd1306_conf.h ssd1306_fonts.c ssd1306_fonts.h oled.c oled.h ASCII.H
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
